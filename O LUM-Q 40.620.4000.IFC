Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: O LUM-Q 40.620.4000.IFC
Time: 2023-12-08T11:00:27
Written by: SwIFC
Made in: SolidWorks 2017

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: O LUM-Q 40.620.4000
In: Default Storey
SolidWorks Custom Properties - Description: O LUM-Q 40.620.4000
PSet_Mass_Property - Mass Measure: 14.66; Area Measure: 0.8768 m2; Volume Measure: 0.01466 m3
